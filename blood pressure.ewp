# IAR project blood pressure.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 200
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Driver\; ; Driver\FATFS\exfuns; Driver\FATFS\src
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c main.h typedefs.h
  group Driver
    Driver/: hal_battery_monitor.c hal_battery_monitor.h hal_BP_measure.c hal_BP_measure.h hal_delay.c hal_delay.h hal_oled.c hal_oled.h hal_rtc_ds1302.c hal_rtc_ds1302.h hal_SDcard.c hal_SDcard.h hal_spi_user.c hal_spi_user.h hal_type.h hal_uart_cc2530.c hal_uart_cc2530.h OLED_FONT.h PingPongBuf.c PingPongBuf.h
  group FATFS
    Driver/FATFS/src/option/: ccsbcs.c
    Driver/FATFS/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    Driver/FATFS/exfuns/: exfuns.c exfuns.h
